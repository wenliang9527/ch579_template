# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: CH579M WCH
  pack: Keil.WCH57x_DFP.1.1.0
  cpu: IROM(0x00000000,0x3E800) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Senlo_ch579_7_1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\library\StdPeriphDriver\inc;..\user;..\ufi_library;..\mem;..\net;..\net_library;..\library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3e800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../user/: main.c uart.c time.c led.c sys_tick.c USARTlist.c
  group library
    ../library/StdPeriphDriver/: CH57x_adc.c CH57x_clk.c CH57x_flash.c CH57x_gpio.c CH57x_int.c CH57x_lcd.c CH57x_pwm.c CH57x_pwr.c CH57x_spi0.c CH57x_spi1.c CH57x_sys.c CH57x_timer0.c CH57x_timer1.c CH57x_timer2.c CH57x_timer3.c CH57x_uart0.c CH57x_uart1.c CH57x_uart2.c CH57x_uart3.c CH57x_usbdev.c CH57x_usbhostBase.c CH57x_usbhostClass.c
  group startup
    ../library/Startup/: startup_ARMCM0.s
  group ufi_library
    ../ufi_library/: CH579UFI.C CH579UFI.lib
  group mem
    ../mem/: BufferManage.c LoopList.c
  group net
    ../net/: net_init.c net_dhcp.c net_dns.c net_tcp_client.c net_tcp_server.c
  group net_library
    ../net_library/: CH57xNET.LIB
